# Keil uVision project gateway.uvprojx, settings and files
target user (6130001::V6.13.1::.\ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: gateway
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group inc
    ../USER/: sec_ask.h sec_convert.h sec_define.h sec_delay.h sec_fsm.h sec_gpio.h sec_message.h sec_sys.h sec_uart.h sec_log.h sec_split_time.h
  group src
    ../USER/: main.c sec_ask.c sec_convert.c sec_delay.c sec_fsm.c sec_gpio.c sec_message.c sec_sys.c sec_uart.c sec_log.c sec_split_time.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, Device:StdPeriph Drivers:TIM 3.6.0, Device:StdPeriph Drivers:USART 3.6.0
