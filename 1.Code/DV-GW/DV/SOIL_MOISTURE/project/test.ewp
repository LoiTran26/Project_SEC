# IAR project test.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\library; ..\user
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: test.srec
  ILINK.IlinkOutputFile: test.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group Header
    ../user/: sec_adc.h sec_answer.h sec_convert.h sec_delay.h sec_gpio.h sec_message.h sec_soil_moisture.h sec_sys.h sec_time.h sec_uart.h
  group library
    ../library/: STM8CONFIG.h stm8s.h stm8s_conf.h stm8s_it.c stm8s_it.h
  group user
    ../user/: main.c sec_adc.c sec_answer.c sec_convert.c sec_delay.c sec_gpio.c sec_message.c sec_soil_moisture.c sec_sys.c sec_time.c sec_uart.c
